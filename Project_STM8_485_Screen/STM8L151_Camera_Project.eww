<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\STM8L151_Camera_Project.ewp</path>
  </project>
  <batchBuild/>
</workspace>


